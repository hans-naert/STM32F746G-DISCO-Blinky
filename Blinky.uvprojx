# Keil uVision project Blinky.uvprojx, settings and files
target STM32F746G-Discovery (6220000::V6.22::ARMCLANG)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.16.0
  cpu: IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) IRAM(0x20010000,0x40000) IRAM2(0x20000000,0x10000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\stm32f746ng.sct
  link misc: --any_placement=first_fit
  group App
    ./: Blinky.c stdout_user.c
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F746NGHx/STCubeGenerated/Src/: main.c stm32f7xx_it.c
    ./RTE/Device/STM32F746NGHx/STCubeGenerated/Inc/: stm32f7xx_it.h
  group STM32CubeMX
    ./RTE/Device/STM32F746NGHx/STCubeGenerated/: STCubeGenerated.ioc
  group Documentation
    ./: README.md
software components: CMSIS-Compiler:CORE 1.1.0, CMSIS-Compiler:STDOUT:Custom 1.1.0, CMSIS-View:Event Recorder 1.6.0, CMSIS:CORE 6.1.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.9.0, Board Support:Drivers:Basic I/O 1.1.1, CMSIS Driver:VIO:Board 2.0.0, Device:STM32Cube Framework:STM32CubeMX 1.1.0, Device:STM32Cube HAL:Common 1.3.0, Device:STM32Cube HAL:Cortex 1.3.0, Device:STM32Cube HAL:DMA 1.3.0, Device:STM32Cube HAL:GPIO 1.3.0, Device:STM32Cube HAL:I2C 1.3.0, Device:STM32Cube HAL:PWR 1.3.0, Device:STM32Cube HAL:RCC 1.3.0, Device:STM32Cube HAL:UART 1.3.0, Device:Startup 1.2.5
